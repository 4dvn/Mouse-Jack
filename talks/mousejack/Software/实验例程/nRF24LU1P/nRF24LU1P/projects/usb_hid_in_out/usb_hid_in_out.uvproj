# Keil uVision project usb_hid_in_out.uvproj, settings and files
target USB_HID_IN_OUT (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: usb_hid_in_out +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\compiler\common;..\..\hal\nrf24lu1p;..\..\hal;..\..\compiler\c51
  group application
    ./: main.c STARTUP.A51
  group hal
    ../../hal/: hal_delay.c
    ../../hal/nrf24lu1p/: hal_usb.c hal_usb_hid.c
  group USB
    ./: usb_desc.c
