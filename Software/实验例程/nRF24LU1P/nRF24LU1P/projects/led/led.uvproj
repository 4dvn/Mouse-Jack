# Keil uVision project led.uvproj, settings and files
target LED_CTRL (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: ledctrl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\compiler\common;..\..\hal\nrf24lu1p;..\..\hal;..\..\hal\nrf24l01p;..\..\compiler\c51
  group application
    ./: main.c
  group hal
    ../../hal/: hal_delay.c
